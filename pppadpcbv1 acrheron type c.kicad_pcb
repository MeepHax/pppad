# Repository MeepHax/pppad

## KiCad design pppadpcbv1 acrheron type c.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C8: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C5: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C7: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D8, D9, D10, D11, D13, D14, D15, D16, D18, D19, D20: 1N4148W; D_SOD-123
D7, D12, D17: D_Small; D_SOD-123
J1: TYPE-C-31-M12_13; TYPE-C-31-M-12
R1: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2, R3: 5.1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R4: 1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5: 330; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R6, R7: 220hms; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: MXSwitch; MX100H
SWP1: SW_Push; smdPushBtn
U1: ATmega32U4-AU; TQPF-44_10x10mm_P0.8mm
Y1: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
+5V: C2.2, C3.2, C4.2, C5.2, J1.A4 (VBUS), J1.B4 (VBUS), R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
Col1: D1.1 (K), D6.1 (K), D11.1 (K), D16.1 (K)
Col2: D2.1 (K), D7.1 (K), D12.1 (K), D17.1 (K), SW16.1 (Col), SW17.1 (Col), SW18.1 (Col), SW19.1 (Col), SW20.1 (Col)
Col3: D3.1 (K), D8.1 (K), D13.1 (K), D18.1 (K)
Col4: D4.1 (K), D9.1 (K), D14.1 (K), D19.1 (K)
Col5: D5.1 (K), D10.1 (K), D15.1 (K), D20.1 (K)
D+: R7.1, U1.4 (D+)
D-: R6.1, U1.3 (D-)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.2, C8.1, J1.A1 (GND), J1.B1 (GND), R2.1, R3.1, R4.2, R5.2, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND)
unnamed: C6.1, U1.17 (XTAL1), Y1.2
unnamed: C7.1, U1.16 (XTAL2), Y1.1
unnamed: C8.2, U1.6 (UCAP)
unnamed: D1.2 (A), SW1.2 (Row)
unnamed: D2.2 (A), SW2.2 (Row)
unnamed: D3.2 (A), SW3.2 (Row)
unnamed: D4.2 (A), SW4.2 (Row)
unnamed: D5.2 (A), SW5.2 (Row)
unnamed: D6.2 (A), SW6.2 (Row)
unnamed: D7.2 (A), SW7.2 (Row)
unnamed: D8.2 (A), SW8.2 (Row)
unnamed: D9.2 (A), SW9.2 (Row)
unnamed: D10.2 (A), SW10.2 (Row)
unnamed: D11.2 (A), SW11.2 (Row)
unnamed: D12.2 (A), SW12.2 (Row)
unnamed: D13.2 (A), SW13.2 (Row)
unnamed: D14.2 (A), SW14.2 (Row)
unnamed: D15.2 (A), SW15.2 (Row)
unnamed: D16.2 (A), SW16.2 (Row)
unnamed: D17.2 (A), SW17.2 (Row)
unnamed: D18.2 (A), SW18.2 (Row)
unnamed: D19.2 (A), SW19.2 (Row)
unnamed: D20.2 (A), SW20.2 (Row)
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.A6 (D+), J1.B6 (D+), R7.2
unnamed: J1.A7 (D-), J1.B7 (D-), R6.2
unnamed: J1.B5 (CC2), R3.2
unnamed: R4.1, U1.33 (~HWB~/PE2)
unnamed: R5.1, SWP1.1
RST: C1.2, R1.2, SWP1.2, U1.13 (~RESET)
Row1: SW1.1 (Col), SW2.1 (Col), SW3.1 (Col), SW4.1 (Col), SW5.1 (Col)
Row2: SW6.1 (Col), SW7.1 (Col), SW8.1 (Col), SW9.1 (Col), SW10.1 (Col)
Row3: SW11.1 (Col), SW12.1 (Col), SW13.1 (Col), SW14.1 (Col), SW15.1 (Col)

Board: 2 copper layers, 59 parts (58 on the bottom side), 42 nets, no tracks yet.

## Commit log

2020-07-01 7/1/2020
    Importing progress
2020-07-02 7/2/2020
    usbc
2020-07-03 7/3/2020
    Archeron USBC
2020-07-04 7/4/2020
    Fixed usbc
